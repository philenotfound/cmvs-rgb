# Repository philenotfound/cmvs-rgb

File README.md:

# cmvs-rgb
NEO GEO MVS to SCART converter board

Parts list:

Part | Value | Footprint
------------ | ------------- | -------------
U1 | THS7374 | SSOP14
R1,R2,R3,R4 | 6800 Ohm | 0805
R5 | 430 Ohm | 0805
R6,R27,R8 | 1400 Ohm | 0805
C1 | 100 nF | 0805
C2,C3,C4,C5 | 220 uF | 8x10

Boards can be ordered via [PCBWay](https://www.pcbway.com/project/shareproject/cmvs_rgb_v2.html), [OSHPark](https://oshpark.com/shared_projects/jzNmi8o1) or somewhere else.

## KiCad design cmvs-rgb.kicad_pcb

Parts:
C1: 0.1uF; C_0805_HandSoldering
C2, C3, C4, C5: 220uF; c_elec_8x10
P1, P2: CONN_01X02; SOLDER-JUMPER_1-WAY
R1, R2, R3, R4: 6k8; R_0805_HandSoldering
R5: 430; R_0805_HandSoldering
R6, R7, R8: 1k4; R_0805_HandSoldering
R9, R10, R11, R12: 75R; R_0805_HandSoldering
U1: THS7374; SSOP-14_5.3x6.2mm_Pitch0.65mm
W1: Jamma_Red; SolderWirePad_single_SMD_3x5mm
W2: Jamma_Blue; SolderWirePad_single_SMD_3x5mm
W3: Jamma_Green; SolderWirePad_single_SMD_3x5mm
W4: Jamma Sync; SolderWirePad_single_SMD_3x5mm
W5: SCART_Red; SolderWirePad_single_SMD_3x5mm
W6: SCART_Blue; SolderWirePad_single_SMD_3x5mm
W7: SCART_Green; SolderWirePad_single_SMD_3x5mm
W8: SCART_Sync; SolderWirePad_single_SMD_3x5mm
W9: GND_IN; SolderWirePad_single_SMD_3x5mm
W10: GND_OUT; SolderWirePad_single_SMD_3x5mm
W11: +5V_IN; SolderWirePad_single_SMD_3x5mm
W12: +5V_OUT; SolderWirePad_single_SMD_3x5mm

Connections:
+5V: C1.1, P1.1, U1.10 (VS+), W11.1, W12.1
GND: C1.2, P2.2, R5.2, R6.2, R7.2, R8.2, U1.5 (GND), U1.6 (DISABLE), W9.1, W10.1
Jamma_Blue: R3.2, W2.1
Jamma_Green: R2.2, W3.1
Jamma_Red: R1.2, W1.1
Jamma_Sync: R4.2, W4.1
unnamed: C2.1, R9.1
unnamed: C3.1, R10.1
unnamed: C4.1, R11.1
unnamed: C5.1, R12.1
unnamed: P1.2, P2.1, U1.9 (BYPASS)
unnamed: R1.1, R8.1, U1.1 (CH1_IN)
unnamed: R2.1, R7.1, U1.2 (CH2_IN)
unnamed: R3.1, R6.1, U1.3 (CH3_IN)
unnamed: R4.1, R5.1, U1.4 (CH4_IN)
unnamed: R9.2, U1.14 (CH1_OUT)
unnamed: R10.2, U1.13 (CH2_OUT)
unnamed: R11.2, U1.12 (CH3_OUT)
unnamed: R12.2, U1.11 (CH4_OUT)
SCART_Blue: C4.2, W7.1
SCART_Green: C3.2, W6.1
SCART_Red: C2.2, W5.1
SCART_Sync: C5.2, W8.1

Board: 2 copper layers, 29.0 x 46.4 mm, 32 parts (0 on the bottom side), 23 nets.

## Commit log

2018-04-05 Initial
2018-04-15 First prototype version
2018-04-15 Pics or it didn't happen
2018-07-10 V2
    * Footprints changed to 0805 for easier soldering
    * Solder pads for enabling/disabling LPF
    * Corrected voltage divider for Sync signal, Sync toned down to 0.3V
    instead of 0.7V
    * Smaller PCB
2018-09-05 Update README and schematics for V2
2019-07-24 Add PCBWay link
